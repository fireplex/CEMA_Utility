options:
  parameters:
    generate_options: qt_gui
    id: telOut
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: selected_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, num_channels=32, threshold=0.01):
              gr.sync_block.__init__(
                  self,
                  name='FHSS Channel Auto-Selector',
                  in_sig=[np.complex64] * num_channels,
                  out_sig=[np.complex64]
              )
              self.num_channels = num_channels
              self.threshold = threshold
              self.active_ch = 0

          def work(self, input_items, output_items):
              # Calculate mean power across current buffer for each channel
              powers = [np.mean(np.abs(input_items[ch])**2) for ch in range(self.num_channels)]
              
              peak_ch = int(np.argmax(powers))
              if powers[peak_ch] > self.threshold:
                  self.active_ch = peak_ch

              # Pass active channel's complex IQ stream straight to output
              output_items[0][:] = input_items[self.active_ch][:]
              return len(output_items[0])
    num_channels: '32'
    threshold: '0.001'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '500000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: '1000000'
    sf: '6'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '50051'
    send_eof: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: '32'
    osr: '1.0'
    taps: firdes.low_pass(1.0, samp_rate, samp_rate/32/2, 100e3)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '8'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: 915e6
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', lora_rx_0, '0']
- [analog_pwr_squelch_xx_0, '0', network_udp_sink_0_0, '0']
- [dc_blocker_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [epy_block_0, '0', rational_resampler_xxx_0, '0']
- [lora_rx_0, '0', network_udp_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '0', epy_block_0, '0']
- [pfb_channelizer_ccf_0, '1', epy_block_0, '1']
- [pfb_channelizer_ccf_0, '10', epy_block_0, '10']
- [pfb_channelizer_ccf_0, '11', epy_block_0, '11']
- [pfb_channelizer_ccf_0, '12', epy_block_0, '12']
- [pfb_channelizer_ccf_0, '13', epy_block_0, '13']
- [pfb_channelizer_ccf_0, '14', epy_block_0, '14']
- [pfb_channelizer_ccf_0, '15', epy_block_0, '15']
- [pfb_channelizer_ccf_0, '16', epy_block_0, '16']
- [pfb_channelizer_ccf_0, '17', epy_block_0, '17']
- [pfb_channelizer_ccf_0, '18', epy_block_0, '18']
- [pfb_channelizer_ccf_0, '19', epy_block_0, '19']
- [pfb_channelizer_ccf_0, '2', epy_block_0, '2']
- [pfb_channelizer_ccf_0, '20', epy_block_0, '20']
- [pfb_channelizer_ccf_0, '21', epy_block_0, '21']
- [pfb_channelizer_ccf_0, '22', epy_block_0, '22']
- [pfb_channelizer_ccf_0, '23', epy_block_0, '23']
- [pfb_channelizer_ccf_0, '24', epy_block_0, '24']
- [pfb_channelizer_ccf_0, '25', epy_block_0, '25']
- [pfb_channelizer_ccf_0, '26', epy_block_0, '26']
- [pfb_channelizer_ccf_0, '27', epy_block_0, '27']
- [pfb_channelizer_ccf_0, '28', epy_block_0, '28']
- [pfb_channelizer_ccf_0, '29', epy_block_0, '29']
- [pfb_channelizer_ccf_0, '3', epy_block_0, '3']
- [pfb_channelizer_ccf_0, '30', epy_block_0, '30']
- [pfb_channelizer_ccf_0, '31', epy_block_0, '31']
- [pfb_channelizer_ccf_0, '4', epy_block_0, '4']
- [pfb_channelizer_ccf_0, '5', epy_block_0, '5']
- [pfb_channelizer_ccf_0, '6', epy_block_0, '6']
- [pfb_channelizer_ccf_0, '7', epy_block_0, '7']
- [pfb_channelizer_ccf_0, '8', epy_block_0, '8']
- [pfb_channelizer_ccf_0, '9', epy_block_0, '9']
- [rational_resampler_xxx_0, '0', dc_blocker_xx_0, '0']
- [soapy_hackrf_source_0, '0', pfb_channelizer_ccf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
